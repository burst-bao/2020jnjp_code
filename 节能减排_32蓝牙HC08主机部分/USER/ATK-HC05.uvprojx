# Keil uVision project ATK-HC05.uvprojx, settings and files
target ATK-HC05 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ATK-HC05 +hex
  c flags: Optim=1 v6Lang=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\USART3;..\HARDWARE\HC05;..\USMART;..\HARDWARE\OLED;..\HARDWARE\CORD
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group user_c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/HC05/: hc05.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/CORD/: menu.c
  group user_h
    ../HARDWARE/CORD/: menu.h
    ../HARDWARE/HC05/: hc05.h
    ../HARDWARE/KEY/: key.h
    ../HARDWARE/LCD/: FONT.H lcd.h
    ../HARDWARE/LED/: led.h
    ../HARDWARE/OLED/: bmp.h oled.h oledfont.h
    ../HARDWARE/TIMER/: timer.h
    ../HARDWARE/USART3/: usart3.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group README
    ../: readme.txt
